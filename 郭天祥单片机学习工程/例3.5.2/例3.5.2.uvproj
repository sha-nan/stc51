# Keil uVision project 例3.5.2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RD+ STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 例3.5.2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 例3.5.2.c

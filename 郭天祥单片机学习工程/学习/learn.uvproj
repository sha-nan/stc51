# Keil uVision project learn.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C51RD+ STC-STC89
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xFFF) CLOCK(45000000) MODP2
  output: learn +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 learn.c
